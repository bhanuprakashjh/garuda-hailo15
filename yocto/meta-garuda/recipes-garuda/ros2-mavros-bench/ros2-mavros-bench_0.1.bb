SUMMARY = "Disabled bench boundary for ROS Jazzy / MAVROS userspace"
LICENSE = "CLOSED"
# Package licenses: see docs/dependencies/ros2-mavros-bench.md. NOT product-cleared.
SRC_URI = ""
COMPATIBLE_MACHINE = "^$"
EXCLUDE_FROM_WORLD = "1"
